Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Capri- Sunbed - ver4.ifc
Time: 2025-11-04T16:52:16
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (299)
Name
 | Capri- Sunbed_0 - ObjectType: SketchupGroup
 | Capri- Sunbed_1 - ObjectType: SketchupGroup
 | Capri- Sunbed_2 - ObjectType: SketchupGroup
 | Capri- Sunbed_3 - ObjectType: SketchupGroup
 | Capri- Sunbed_4 - ObjectType: SketchupGroup
 | Capri- Sunbed_5 - ObjectType: SketchupGroup
 | Capri- Sunbed_6 - ObjectType: SketchupGroup
 | Capri- Sunbed_7 - ObjectType: SketchupGroup
 | Capri- Sunbed_8 - ObjectType: SketchupGroup
 | Capri- Sunbed_9 - ObjectType: SketchupGroup
 | Capri- Sunbed_10 - ObjectType: SketchupGroup
 | Capri- Sunbed_11 - ObjectType: SketchupGroup
 | Capri- Sunbed_12 - ObjectType: SketchupGroup
 | Capri- Sunbed_13 - ObjectType: SketchupGroup
 | Capri- Sunbed_14 - ObjectType: SketchupGroup
 | Capri- Sunbed_15 - ObjectType: SketchupGroup
 | Capri- Sunbed_16 - ObjectType: SketchupGroup
 | Capri- Sunbed_17 - ObjectType: SketchupGroup
 | Capri- Sunbed_18 - ObjectType: SketchupGroup
 | Capri- Sunbed_19 - ObjectType: SketchupGroup
 | Capri- Sunbed_20 - ObjectType: SketchupGroup
 | Capri- Sunbed_21 - ObjectType: SketchupGroup
 | Capri- Sunbed_22 - ObjectType: SketchupGroup
 | Capri- Sunbed_23 - ObjectType: SketchupGroup
 | Capri- Sunbed_24 - ObjectType: SketchupGroup
 | Capri- Sunbed_25 - ObjectType: SketchupGroup
 | Capri- Sunbed_26 - ObjectType: SketchupGroup
 | Capri- Sunbed_27 - ObjectType: SketchupGroup
 | Capri- Sunbed_28 - ObjectType: SketchupGroup
 | Capri- Sunbed_29 - ObjectType: SketchupGroup
 | Capri- Sunbed_30 - ObjectType: SketchupGroup
 | Capri- Sunbed_31 - ObjectType: SketchupGroup
 | Capri- Sunbed_32 - ObjectType: SketchupGroup
 | Capri- Sunbed_33 - ObjectType: SketchupGroup
 | Capri- Sunbed_34 - ObjectType: SketchupGroup
 | Capri- Sunbed_35 - ObjectType: SketchupGroup
 | Capri- Sunbed_36 - ObjectType: SketchupGroup
 | Capri- Sunbed_37 - ObjectType: SketchupGroup
 | Capri- Sunbed_38 - ObjectType: SketchupGroup
 | Capri- Sunbed_39 - ObjectType: SketchupGroup
 | Capri- Sunbed_40 - ObjectType: SketchupGroup
 | Capri- Sunbed_41 - ObjectType: SketchupGroup
 | Capri- Sunbed_42 - ObjectType: SketchupGroup
 | Capri- Sunbed_43 - ObjectType: SketchupGroup
 | Capri- Sunbed_44 - ObjectType: SketchupGroup
 | Capri- Sunbed_45 - ObjectType: SketchupGroup
 | Capri- Sunbed_46 - ObjectType: SketchupGroup
 | Capri- Sunbed_47 - ObjectType: SketchupGroup
 | Capri- Sunbed_48 - ObjectType: SketchupGroup
 | Capri- Sunbed_49 - ObjectType: SketchupGroup
 | Capri- Sunbed_50 - ObjectType: SketchupGroup
 | Capri- Sunbed_51 - ObjectType: SketchupGroup
 | Capri- Sunbed_52 - ObjectType: SketchupGroup
 | Capri- Sunbed_53 - ObjectType: SketchupGroup
 | Capri- Sunbed_54 - ObjectType: SketchupGroup
 | Capri- Sunbed_55 - ObjectType: SketchupGroup
 | Capri- Sunbed_56 - ObjectType: SketchupGroup
 | Capri- Sunbed_57 - ObjectType: SketchupGroup
 | Capri- Sunbed_58 - ObjectType: SketchupGroup
 | Capri- Sunbed_59 - ObjectType: SketchupGroup
 | Capri- Sunbed_60 - ObjectType: SketchupGroup
 | Capri- Sunbed_61 - ObjectType: SketchupGroup
 | Capri- Sunbed_62 - ObjectType: SketchupGroup
 | Capri- Sunbed_63 - ObjectType: SketchupGroup
 | Capri- Sunbed_64 - ObjectType: SketchupGroup
 | Capri- Sunbed_65 - ObjectType: SketchupGroup
 | Capri- Sunbed_270 - ObjectType: SketchupGroup
 | Capri- Sunbed_271 - ObjectType: SketchupGroup
 | Capri- Sunbed_272 - ObjectType: SketchupGroup
 | Capri- Sunbed_273 - ObjectType: SketchupGroup
 | Capri- Sunbed_274 - ObjectType: SketchupGroup
 | Capri- Sunbed_275 - ObjectType: SketchupGroup
 | Capri- Sunbed_276 - ObjectType: SketchupGroup
 | Capri- Sunbed_277 - ObjectType: SketchupGroup
 | Capri- Sunbed_278 - ObjectType: SketchupGroup
 | Capri- Sunbed_279 - ObjectType: SketchupGroup
 | Capri- Sunbed_280 - ObjectType: SketchupGroup
 | Capri- Sunbed_281 - ObjectType: SketchupGroup
 | Capri- Sunbed_282 - ObjectType: SketchupGroup
 | Capri- Sunbed_283 - ObjectType: SketchupGroup
 | Capri- Sunbed_284 - ObjectType: SketchupGroup
 | Capri- Sunbed_285 - ObjectType: SketchupGroup
 | Capri- Sunbed_286 - ObjectType: SketchupGroup
 | Capri- Sunbed_287 - ObjectType: SketchupGroup
 | Capri- Sunbed_288 - ObjectType: SketchupGroup
 | Capri- Sunbed_289 - ObjectType: SketchupGroup
 | Capri- Sunbed_290 - ObjectType: SketchupGroup
 | Capri- Sunbed_291 - ObjectType: SketchupGroup
 | Capri- Sunbed_292 - ObjectType: SketchupGroup
 | Capri- Sunbed_293 - ObjectType: SketchupGroup
 | Capri- Sunbed_294 - ObjectType: SketchupGroup
 | Capri- Sunbed_295 - ObjectType: SketchupGroup
 | Capri- Sunbed_296 - ObjectType: SketchupGroup
 | Capri- Sunbed_297 - ObjectType: SketchupGroup
 | Capri- Sunbed_298 - ObjectType: SketchupGroup
 | Capri- Sunbed_202 - ObjectType: SketchupGroup
 | Capri- Sunbed_203 - ObjectType: SketchupGroup
 | Capri- Sunbed_204 - ObjectType: SketchupGroup
 | Capri- Sunbed_205 - ObjectType: SketchupGroup
 | Capri- Sunbed_206 - ObjectType: SketchupGroup
 | Capri- Sunbed_207 - ObjectType: SketchupGroup
 | Capri- Sunbed_208 - ObjectType: SketchupGroup
 | Capri- Sunbed_209 - ObjectType: SketchupGroup
 | Capri- Sunbed_210 - ObjectType: SketchupGroup
 | Capri- Sunbed_211 - ObjectType: SketchupGroup
 | Capri- Sunbed_212 - ObjectType: SketchupGroup
 | Capri- Sunbed_213 - ObjectType: SketchupGroup
 | Capri- Sunbed_214 - ObjectType: SketchupGroup
 | Capri- Sunbed_215 - ObjectType: SketchupGroup
 | Capri- Sunbed_216 - ObjectType: SketchupGroup
 | Capri- Sunbed_217 - ObjectType: SketchupGroup
 | Capri- Sunbed_218 - ObjectType: SketchupGroup
 | Capri- Sunbed_219 - ObjectType: SketchupGroup
 | Capri- Sunbed_220 - ObjectType: SketchupGroup
 | Capri- Sunbed_221 - ObjectType: SketchupGroup
 | Capri- Sunbed_222 - ObjectType: SketchupGroup
 | Capri- Sunbed_223 - ObjectType: SketchupGroup
 | Capri- Sunbed_224 - ObjectType: SketchupGroup
 | Capri- Sunbed_225 - ObjectType: SketchupGroup
 | Capri- Sunbed_226 - ObjectType: SketchupGroup
 | Capri- Sunbed_227 - ObjectType: SketchupGroup
 | Capri- Sunbed_228 - ObjectType: SketchupGroup
 | Capri- Sunbed_229 - ObjectType: SketchupGroup
 | Capri- Sunbed_230 - ObjectType: SketchupGroup
 | Capri- Sunbed_231 - ObjectType: SketchupGroup
 | Capri- Sunbed_232 - ObjectType: SketchupGroup
 | Capri- Sunbed_233 - ObjectType: SketchupGroup
 | Capri- Sunbed_234 - ObjectType: SketchupGroup
 | Capri- Sunbed_235 - ObjectType: SketchupGroup
 | Capri- Sunbed_236 - ObjectType: SketchupGroup
 | Capri- Sunbed_237 - ObjectType: SketchupGroup
 | Capri- Sunbed_238 - ObjectType: SketchupGroup
 | Capri- Sunbed_239 - ObjectType: SketchupGroup
 | Capri- Sunbed_240 - ObjectType: SketchupGroup
 | Capri- Sunbed_241 - ObjectType: SketchupGroup
 | Capri- Sunbed_242 - ObjectType: SketchupGroup
 | Capri- Sunbed_243 - ObjectType: SketchupGroup
 | Capri- Sunbed_244 - ObjectType: SketchupGroup
 | Capri- Sunbed_245 - ObjectType: SketchupGroup
 | Capri- Sunbed_246 - ObjectType: SketchupGroup
 | Capri- Sunbed_247 - ObjectType: SketchupGroup
 | Capri- Sunbed_248 - ObjectType: SketchupGroup
 | Capri- Sunbed_249 - ObjectType: SketchupGroup
 | Capri- Sunbed_250 - ObjectType: SketchupGroup
 | Capri- Sunbed_251 - ObjectType: SketchupGroup
 | Capri- Sunbed_252 - ObjectType: SketchupGroup
 | Capri- Sunbed_253 - ObjectType: SketchupGroup
 | Capri- Sunbed_254 - ObjectType: SketchupGroup
 | Capri- Sunbed_255 - ObjectType: SketchupGroup
 | Capri- Sunbed_256 - ObjectType: SketchupGroup
 | Capri- Sunbed_257 - ObjectType: SketchupGroup
 | Capri- Sunbed_258 - ObjectType: SketchupGroup
 | Capri- Sunbed_259 - ObjectType: SketchupGroup
 | Capri- Sunbed_260 - ObjectType: SketchupGroup
 | Capri- Sunbed_261 - ObjectType: SketchupGroup
 | Capri- Sunbed_262 - ObjectType: SketchupGroup
 | Capri- Sunbed_263 - ObjectType: SketchupGroup
 | Capri- Sunbed_264 - ObjectType: SketchupGroup
 | Capri- Sunbed_265 - ObjectType: SketchupGroup
 | Capri- Sunbed_266 - ObjectType: SketchupGroup
 | Capri- Sunbed_267 - ObjectType: SketchupGroup
 | Capri- Sunbed_268 - ObjectType: SketchupGroup
 | Capri- Sunbed_269 - ObjectType: SketchupGroup
 | Capri- Sunbed_134 - ObjectType: SketchupGroup
 | Capri- Sunbed_135 - ObjectType: SketchupGroup
 | Capri- Sunbed_136 - ObjectType: SketchupGroup
 | Capri- Sunbed_137 - ObjectType: SketchupGroup
 | Capri- Sunbed_138 - ObjectType: SketchupGroup
 | Capri- Sunbed_139 - ObjectType: SketchupGroup
 | Capri- Sunbed_140 - ObjectType: SketchupGroup
 | Capri- Sunbed_141 - ObjectType: SketchupGroup
 | Capri- Sunbed_142 - ObjectType: SketchupGroup
 | Capri- Sunbed_143 - ObjectType: SketchupGroup
 | Capri- Sunbed_144 - ObjectType: SketchupGroup
 | Capri- Sunbed_145 - ObjectType: SketchupGroup
 | Capri- Sunbed_146 - ObjectType: SketchupGroup
 | Capri- Sunbed_147 - ObjectType: SketchupGroup
 | Capri- Sunbed_148 - ObjectType: SketchupGroup
 | Capri- Sunbed_149 - ObjectType: SketchupGroup
 | Capri- Sunbed_150 - ObjectType: SketchupGroup
 | Capri- Sunbed_151 - ObjectType: SketchupGroup
 | Capri- Sunbed_152 - ObjectType: SketchupGroup
 | Capri- Sunbed_153 - ObjectType: SketchupGroup
 | Capri- Sunbed_154 - ObjectType: SketchupGroup
 | Capri- Sunbed_155 - ObjectType: SketchupGroup
 | Capri- Sunbed_156 - ObjectType: SketchupGroup
 | Capri- Sunbed_157 - ObjectType: SketchupGroup
 | Capri- Sunbed_158 - ObjectType: SketchupGroup
 | Capri- Sunbed_159 - ObjectType: SketchupGroup
 | Capri- Sunbed_160 - ObjectType: SketchupGroup
 | Capri- Sunbed_161 - ObjectType: SketchupGroup
 | Capri- Sunbed_162 - ObjectType: SketchupGroup
 | Capri- Sunbed_163 - ObjectType: SketchupGroup
 | Capri- Sunbed_164 - ObjectType: SketchupGroup
 | Capri- Sunbed_165 - ObjectType: SketchupGroup
 | Capri- Sunbed_166 - ObjectType: SketchupGroup
 | Capri- Sunbed_167 - ObjectType: SketchupGroup
 | Capri- Sunbed_168 - ObjectType: SketchupGroup
 | Capri- Sunbed_169 - ObjectType: SketchupGroup
 | Capri- Sunbed_170 - ObjectType: SketchupGroup
 | Capri- Sunbed_171 - ObjectType: SketchupGroup
 | Capri- Sunbed_172 - ObjectType: SketchupGroup
 | Capri- Sunbed_173 - ObjectType: SketchupGroup
 | Capri- Sunbed_174 - ObjectType: SketchupGroup
 | Capri- Sunbed_175 - ObjectType: SketchupGroup
 | Capri- Sunbed_176 - ObjectType: SketchupGroup
 | Capri- Sunbed_177 - ObjectType: SketchupGroup
 | Capri- Sunbed_178 - ObjectType: SketchupGroup
 | Capri- Sunbed_179 - ObjectType: SketchupGroup
 | Capri- Sunbed_180 - ObjectType: SketchupGroup
 | Capri- Sunbed_181 - ObjectType: SketchupGroup
 | Capri- Sunbed_182 - ObjectType: SketchupGroup
 | Capri- Sunbed_183 - ObjectType: SketchupGroup
 | Capri- Sunbed_184 - ObjectType: SketchupGroup
 | Capri- Sunbed_185 - ObjectType: SketchupGroup
 | Capri- Sunbed_186 - ObjectType: SketchupGroup
 | Capri- Sunbed_187 - ObjectType: SketchupGroup
 | Capri- Sunbed_188 - ObjectType: SketchupGroup
 | Capri- Sunbed_189 - ObjectType: SketchupGroup
 | Capri- Sunbed_190 - ObjectType: SketchupGroup
 | Capri- Sunbed_191 - ObjectType: SketchupGroup
 | Capri- Sunbed_192 - ObjectType: SketchupGroup
 | Capri- Sunbed_193 - ObjectType: SketchupGroup
 | Capri- Sunbed_194 - ObjectType: SketchupGroup
 | Capri- Sunbed_195 - ObjectType: SketchupGroup
 | Capri- Sunbed_196 - ObjectType: SketchupGroup
 | Capri- Sunbed_197 - ObjectType: SketchupGroup
 | Capri- Sunbed_198 - ObjectType: SketchupGroup
 | Capri- Sunbed_199 - ObjectType: SketchupGroup
 | Capri- Sunbed_200 - ObjectType: SketchupGroup
 | Capri- Sunbed_201 - ObjectType: SketchupGroup
 | Capri- Sunbed_66 - ObjectType: SketchupGroup
 | Capri- Sunbed_67 - ObjectType: SketchupGroup
 | Capri- Sunbed_68 - ObjectType: SketchupGroup
 | Capri- Sunbed_69 - ObjectType: SketchupGroup
 | Capri- Sunbed_70 - ObjectType: SketchupGroup
 | Capri- Sunbed_71 - ObjectType: SketchupGroup
 | Capri- Sunbed_72 - ObjectType: SketchupGroup
 | Capri- Sunbed_73 - ObjectType: SketchupGroup
 | Capri- Sunbed_74 - ObjectType: SketchupGroup
 | Capri- Sunbed_75 - ObjectType: SketchupGroup
 | Capri- Sunbed_76 - ObjectType: SketchupGroup
 | Capri- Sunbed_77 - ObjectType: SketchupGroup
 | Capri- Sunbed_78 - ObjectType: SketchupGroup
 | Capri- Sunbed_79 - ObjectType: SketchupGroup
 | Capri- Sunbed_80 - ObjectType: SketchupGroup
 | Capri- Sunbed_81 - ObjectType: SketchupGroup
 | Capri- Sunbed_82 - ObjectType: SketchupGroup
 | Capri- Sunbed_83 - ObjectType: SketchupGroup
 | Capri- Sunbed_84 - ObjectType: SketchupGroup
 | Capri- Sunbed_85 - ObjectType: SketchupGroup
 | Capri- Sunbed_86 - ObjectType: SketchupGroup
 | Capri- Sunbed_87 - ObjectType: SketchupGroup
 | Capri- Sunbed_88 - ObjectType: SketchupGroup
 | Capri- Sunbed_89 - ObjectType: SketchupGroup
 | Capri- Sunbed_90 - ObjectType: SketchupGroup
 | Capri- Sunbed_91 - ObjectType: SketchupGroup
 | Capri- Sunbed_92 - ObjectType: SketchupGroup
 | Capri- Sunbed_93 - ObjectType: SketchupGroup
 | Capri- Sunbed_94 - ObjectType: SketchupGroup
 | Capri- Sunbed_95 - ObjectType: SketchupGroup
 | Capri- Sunbed_96 - ObjectType: SketchupGroup
 | Capri- Sunbed_97 - ObjectType: SketchupGroup
 | Capri- Sunbed_98 - ObjectType: SketchupGroup
 | Capri- Sunbed_99 - ObjectType: SketchupGroup
 | Capri- Sunbed_100 - ObjectType: SketchupGroup
 | Capri- Sunbed_101 - ObjectType: SketchupGroup
 | Capri- Sunbed_102 - ObjectType: SketchupGroup
 | Capri- Sunbed_103 - ObjectType: SketchupGroup
 | Capri- Sunbed_104 - ObjectType: SketchupGroup
 | Capri- Sunbed_105 - ObjectType: SketchupGroup
 | Capri- Sunbed_106 - ObjectType: SketchupGroup
 | Capri- Sunbed_107 - ObjectType: SketchupGroup
 | Capri- Sunbed_108 - ObjectType: SketchupGroup
 | Capri- Sunbed_109 - ObjectType: SketchupGroup
 | Capri- Sunbed_110 - ObjectType: SketchupGroup
 | Capri- Sunbed_111 - ObjectType: SketchupGroup
 | Capri- Sunbed_112 - ObjectType: SketchupGroup
 | Capri- Sunbed_113 - ObjectType: SketchupGroup
 | Capri- Sunbed_114 - ObjectType: SketchupGroup
 | Capri- Sunbed_115 - ObjectType: SketchupGroup
 | Capri- Sunbed_116 - ObjectType: SketchupGroup
 | Capri- Sunbed_117 - ObjectType: SketchupGroup
 | Capri- Sunbed_118 - ObjectType: SketchupGroup
 | Capri- Sunbed_119 - ObjectType: SketchupGroup
 | Capri- Sunbed_120 - ObjectType: SketchupGroup
 | Capri- Sunbed_121 - ObjectType: SketchupGroup
 | Capri- Sunbed_122 - ObjectType: SketchupGroup
 | Capri- Sunbed_123 - ObjectType: SketchupGroup
 | Capri- Sunbed_124 - ObjectType: SketchupGroup
 | Capri- Sunbed_125 - ObjectType: SketchupGroup
 | Capri- Sunbed_126 - ObjectType: SketchupGroup
 | Capri- Sunbed_127 - ObjectType: SketchupGroup
 | Capri- Sunbed_128 - ObjectType: SketchupGroup
 | Capri- Sunbed_129 - ObjectType: SketchupGroup
 | Capri- Sunbed_130 - ObjectType: SketchupGroup
 | Capri- Sunbed_131 - ObjectType: SketchupGroup
 | Capri- Sunbed_132 - ObjectType: SketchupGroup
 | Capri- Sunbed_133 - ObjectType: SketchupGroup
